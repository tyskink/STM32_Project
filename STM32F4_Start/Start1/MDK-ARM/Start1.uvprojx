# Keil uVision project Start1.uvprojx, settings and files
target Start1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Start1
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src/drivers;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Include;..\..\..\..\STM32_Project
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: main.c stm32f4xx_it.c bsp_driver_sd.c stm32f4xx_hal_msp.c
    ../../../: LK_fatfs.c LK_fatfs.h LK_STM32.c LK_STM32.h
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff_gen_drv.c ff.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_sd.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_ll_sdmmc.c
software components: CMSIS:CORE 4.1.0
