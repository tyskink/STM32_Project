# Keil uVision project A9_TEST1.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MCIMX6X3:Cortex-M4 NXP
  pack: Keil.iMX6_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: A9_TEST1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
